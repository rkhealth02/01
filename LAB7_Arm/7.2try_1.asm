		
		AREA    RESET, DATA, READONLY
		AREA SWITCHLED, CODE, READONLY

START	LDR R0, =0XE0028008
		MOV R1, #0XFFFFFFFF
		STR R1, [R0]
		LDR R5, =0XE0028018
		MOV R6, #0X0
		STR R6, [R5]
		LDR R7, =0XE0028010
		MOV R9, #0X0
		STR R9, [R7]
		LDR R8, [R7]
		MOV R10, #0X80000000
		CMP R8, R10
		BNE LP
		LDR R1, =0XAAAAAAAA
LP		LDR R2, =0XE0028004
		STR R1, [R2]
		BL DELAY
		LDR R3, =0XE002800C
		STR R1, [R3]
		BL    DELAY
		B START
DELAY	LDR R4, =0X00FFFFFF
		SUBS R4, R4, #0X01
		BNE LP
		BX LR
		END
